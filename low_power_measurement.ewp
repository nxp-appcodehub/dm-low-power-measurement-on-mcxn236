# IAR project low_power_measurement.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN236 NXP MCXN236
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN236VDF; MCUXPRESSO_SDK; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; WAKEUP_EN=0
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/uart; device; drivers; frdmmcxn236/demo_apps/power_mode_switch/low_level; utilities; IDD_General
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: low_power_measurement.srec
  ILINK.IlinkOutputFile: low_power_measurement.out
  ILINK.IlinkIcfFile: MCXN236/iar/MCXN236_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; CPU_MCXN236VDF; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/uart; device; drivers; frdmmcxn236/demo_apps/power_mode_switch/low_level; utilities
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MCXN236.h MCXN236_features.h system_MCXN236.c system_MCXN236.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_cmc.c fsl_cmc.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_reset.c fsl_reset.h fsl_spc.c fsl_spc.h fsl_wuu.c fsl_wuu.h
  group IDD_General
    IDD_General/: idd_cmc_cfg.c idd_cmc_cfg.h idd_general_cfg.c idd_general_cfg.h idd_mode_select.c idd_mode_select.h idd_scg_cfg.c idd_scg_cfg.h idd_spc_cfg.c idd_spc_cfg.h idd_syscon_cfg.c idd_syscon_cfg.h
  group MCXN236/iar
    MCXN236/iar/: MCXN236_flash.icf
  group source
    source/: IDD.c IDD.h
  group startup
    startup/: startup_MCXN236.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
